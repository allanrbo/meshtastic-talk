options:
  parameters:
    generate_options: qt_gui
    id: lora_module_experiment
    output_language: python
    run_options: run
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: |-
      This is to workaround
      HackRF's DC spike.
      Remove with other SDRs.
    value: '914875000'
  states: {}
- name: center_freq_offset
  id: variable_qtgui_range
  parameters:
    comment: |-
      This is to workaround
      HackRF's DC spike.
      Remove with other SDRs.
    start: '-10e6'
    step: '1000'
    stop: 10e6
    value: '-1e6'
  states: {}
- name: center_freq_offset
  id: variable
  parameters:
    comment: alternative, if the QT GUI is disabled
    value: '-1e6'
  states: {state: disabled}
- name: cr
  id: variable
  parameters:
    value: '1'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '255'
  states: {}
- name: preamb_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: sf
  id: variable
  parameters:
    value: '10'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: sync_word
  id: variable
  parameters:
    comment: |-
      Looks like sync_word of 0
      makes it skip sync word check.
    value: '0'
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: bw/2
    gain: '1.0'
    samp_rate: samp_rate
    width: 400e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: samples/text_message_913875000_8000000_fc.raw
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_2
  id: blocks_file_source
  parameters:
    comment: delta_f = -2355000
    file: samples/userinfo_exch_913875000_8000000_fc.raw
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    minoutbuf: '65536'
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0_1_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class payload_crc_sink(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="payload_crc_sink",
                  in_sig=[np.uint8, np.uint8],
                  out_sig=[]
              )

              # message output port
              self._out_port = pmt.intern("out")
              self.message_port_register_out(self._out_port)

          def general_work(self, input_items, output_items):
              payload = input_items[0]
              crc_check   = input_items[1]

              if len(crc_check) == 0:
                  return

              crc_ok = bool(crc_check[0])
              if not crc_ok:
                  print("Bad CRC. Frame dropped.")
              else:
                  pkt = bytes(payload)
                  if crc_ok and pkt:
                      vec = pmt.to_pmt(np.frombuffer(pkt, dtype=np.uint8))
                      self.message_port_pub(self._out_port, vec)

              self.consume(0, len(payload))
              self.consume(1, len(crc_check))
              return 0
    comment: |-
      Seems there's a bug with payload_char tags.
      And "CRC Verif"'s msg output doesn't tell
      whether CRC was valid or not.
      Therefore we use this strange combiner
      block, that keeps trying bytes to read from
      payload_char output until it is also able to
      get 1 byte from the crc_check outupt.
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-center_freq_offset'
    comment: Move signal to 0 and filter to bandwidth
    decim: decimation
    minoutbuf: '65536'
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'True'
    print_rx_msg: '0'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    comment: Spread bits over multiple symbols
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters:
    comment: |-
      De-scrambling for
      long-run avoidance
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    comment: |-
      Thanks Joachim Tapparel 
      for these LoRa demod+decode blocks!
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    center_freq: int(center_freq)
    impl_head: impl_head
    minoutbuf: '65536'
    os_factor: int((samp_rate/decimation)/bw)
    preamb_len: preamb_len
    sf: sf
    show_log_port: 'False'
    sync_word: sync_word
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    comment: Reduce impact of errors
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    comment: Forward error correction
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: pay_len
    print_header: 'False'
  states: {}
- name: meshtastic_parse_0
  id: meshtastic_parse
  parameters:
    decrypt: 'True'
    encryption_keys: '{"MediumSlow": "1PG7OiApB1nwvP+rz05pAQ==", "equalbeat": "06lGUq+WhpsOt/weuKcesGzFVZ6HQx3rwWyS8liJhzY="}'
    print_msg: 'False'
  states: {}
- name: print_bytes_0
  id: print_bytes
  parameters:
    prefix: '"Deinterleaver  "'
  states: {state: disabled}
- name: print_bytes_1
  id: print_bytes
  parameters:
    prefix: '"Hamming dec    "'
  states: {state: disabled}
- name: print_bytes_2
  id: print_bytes
  parameters:
    prefix: '"Header decoder "'
  states: {state: disabled}
- name: print_bytes_3
  id: print_bytes
  parameters:
    prefix: '"Dewhitening    "'
  states: {state: disabled}
- name: print_bytes_4
  id: print_bytes
  parameters:
    prefix: '"CRC verif      "'
  states: {state: disabled}
- name: print_int16_0
  id: print_int16
  parameters:
    comment: |-
      With spread factor of 7
      we should expect 2^7=128
      as max symbol
    prefix: '"fft_demod      "'
  states: {}
- name: print_int16_1
  id: print_int16
  parameters:
    prefix: '"Gray mapping   "'
  states: {state: disabled}
- name: print_tags_0
  id: print_tags
  parameters:
    prefix: '"Frame sync    "'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: '0'
    fftsize: '1024'
    type: complex
    update_time: '0.01'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: center_freq + center_freq_offset
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: wireshark_udpdump_0
  id: wireshark_udpdump
  parameters:
    prefix_bytes: b"_meshtastic_____"
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0_0, '0']
- [blocks_file_source_0_2, '0', blocks_throttle_0_0, '0']
- [blocks_throttle_0_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [epy_block_0_1_1, out, meshtastic_parse_0, msg]
- [freq_xlating_fir_filter_xxx_0, '0', lora_sdr_frame_sync_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [lora_sdr_crc_verif_0, '0', epy_block_0_1_1, '0']
- [lora_sdr_crc_verif_0, '0', print_bytes_4, '0']
- [lora_sdr_crc_verif_0, '1', epy_block_0_1_1, '1']
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_deinterleaver_0, '0', print_bytes_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_dewhitening_0, '0', print_bytes_3, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_fft_demod_0, '0', print_int16_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_frame_sync_0, '0', print_tags_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_gray_mapping_0, '0', print_int16_1, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_hamming_dec_0, '0', print_bytes_1, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, '0', print_bytes_2, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [meshtastic_parse_0, msg_out, wireshark_udpdump_0, msg]
- [soapy_hackrf_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
